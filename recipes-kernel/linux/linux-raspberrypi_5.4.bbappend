# Change linux kernel to support raspberry pi cm4
LINUX_VERSION = "5.4.83"
SRCREV_machine = "ec0dcf3064b8ba99f226438214407fcea9870f76"
LIC_FILES_CHKSUM = "file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814"
